# Keil uVision project APP.uvproj, settings and files
target APP (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: APP
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP\INC;..\STM32F10x_FWLib\INC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: app.c core_cm3.c core_cm3.h includes.h startup_stm32f10x_md.s stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h codeTemplate.txt deftype.h
  group BSP
    ../BSP/SRC/: bsp_delay.c bsp_led.c bsp_usart.c bsp_servo.c bsp_dma.c
  group ST_Lib
    ../STM32F10x_FWLib/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
